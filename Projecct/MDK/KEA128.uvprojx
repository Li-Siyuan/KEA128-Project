# Keil uVision project KEA128.uvprojx, settings and files
target KEA128 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: SKEAZ128xxx4 NXP
  pack: Keil.Kinetis_KEAxx_DFP.1.3.0
  cpu: IRAM(0x1FFFF000,0x00004000) IROM(0x00000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: KEA128
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\USER\inc;..\USER\src;..\..\Libraries\drives\inc;..\..\Libraries\drives\src;..\..\Libraries\seekfree;..\..\Libraries\startup\CoreSupport;..\..\Libraries\startup;..\..\Libraries\startup\DeviceSupport;..\..\Libraries\startup\DeviceSupport\MDK-ARM;..\my_fun\moni_iic;..\my_fun\mpu6050;..\my_fun\nvic;..\my_fun\oled;..\my_fun\my_nrf;..\PRJ;..\PRJ;..\PRJ
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group startup
    ../../Libraries/startup/DeviceSupport/MDK-ARM/: startup_SKEAZ1284.s
    ../../Libraries/startup/DeviceSupport/: system_SKEAZ1284.c
  group drives_c
    ../../Libraries/drives/src/: misc.c common.c KEA128_adc.c KEA128_flash.c KEA128_ftm.c KEA128_gpio.c KEA128_irq.c KEA128_kbi.c KEA128_pit.c KEA128_port.c KEA128_uart.c KEA128_systick.c KEA128_i2c.c KEA128_spi.c
  group drives_h
    ../../Libraries/drives/inc/: common.h headfile.h KEA128_flash.h KEA128_ftm.h KEA128_adc.h KEA128_gpio.h KEA128_i2c.h KEA128_irq.h KEA128_kbi.h KEA128_pit.h KEA128_port.h KEA128_port_cfg.h KEA128_spi.h KEA128_systick.h KEA128_uart.h misc.h
  group seekfree
    ../../Libraries/seekfree/: font.h SEEKFREE_FUN.c SEEKFREE_FUN.h SEEKFREE_IIC.c SEEKFREE_IIC.h SEEKFREE_MPU6050.c
  group user_c
    ../USER/src/: isr.c main.c
    ../../Libraries/: version.txt
  group user_h
    ../../Libraries/drives/inc/: headfile.h
    ../USER/inc/: isr.h
  group my_fun
    ../my_fun/nvic/: nvic.c nvic.h
    ../my_fun/oled/: oled_iic.c oled_iic.h codetab.c codetab.h
    ../my_fun/my_nrf/: my_nrf.c my_nrf.h
  group PRJ
    ../PRJ/: control.c control.h filter.c filter.h init.c init.h protoco.c protoco.h angle.c angle.h speed.c speed.h turn.c turn.h key.c key.h master.c master.h COMPUTER.c COMPUTER.h
